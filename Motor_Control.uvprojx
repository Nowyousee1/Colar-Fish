# Keil uVision project Motor_Control.uvprojx, settings and files
target Motor_Control (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Motor_Control +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F407xx
  c include: .;.\CMSIS\Include;.\CMSIS\Device\ST\STM32F4xx\Include;.\USER;.\SYSTEM\delay;.\SYSTEM\usart;.\HARDWARE\pwm;.\HARDWARE\motor;.\HARDWARE\relay;.\HARDWARE\stepper;.\HARDWARE\dc_motor
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./CORE/: startup_stm32f407xx.s
  group CMSIS
    ./CMSIS/Device/ST/STM32F4xx/Source/: system_stm32f4xx.c
    ./CMSIS/Device/ST/STM32F4xx/Include/: system_stm32f4xx.h stm32f4xx.h stm32f407xx.h
  group User
    ./USER/: main.c main.h stm32f4xx_it.c stm32f4xx_it.h
  group SYSTEM
    ./SYSTEM/delay/: delay.c delay.h
    ./SYSTEM/usart/: usart.c usart.h
  group HARDWARE
    ./HARDWARE/pwm/: pwm.c pwm.h
    ./HARDWARE/motor/: motor.c motor.h
    ./HARDWARE/relay/: relay.c relay.h
    ./HARDWARE/stepper/: stepper.c stepper.h
